ORG 000H

MAIN:	MOV R7,#00H
L1:		MOV A,R7
		CALL TRABANG
		MOV P2,A
		CALL DELAYS
		INC R7
		CJNE R7,#0AH,L1
		JMP MAIN

TRABANG:INC A
		MOVC A,@A+PC
		RET
BANGMA:	DB 40H,79H,24H,30H,19H,12H,02H,78H,00H,10H				

DELAYH: MOV R4,#0FH
LOOPD:	MOV R5,#0F0H
LOOPE:	CALL DELAYS
		DJNZ R3,LOOPE
		DJNZ R2,LOOPD
		RET

DELAYS: MOV R2,#01H
LOOPB:	MOV R3,#0FAH
LOOPC:	CALL DELAYMS
		DJNZ R3,LOOPC
		DJNZ R2,LOOPB
		RET	

DELAYMS:MOV R1,#0FAH	
LOOPA:	NOP
		NOP
		DJNZ R1,LOOPA
		RET
END
